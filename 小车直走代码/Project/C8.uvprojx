# Keil uVision project C8.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: C8 +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c misc: --c99
  c include: ..\Project
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Source Group 1
    ./: main.c encoder.c delay.c sys.c pwm.c nvic.c motor.c usart.c exti.c oled.c myiic.c
software components: CMSIS:CORE 3.40.0, Device:Startup 1.0.0
